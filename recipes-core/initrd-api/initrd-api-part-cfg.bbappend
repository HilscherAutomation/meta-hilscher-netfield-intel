FILESEXTRAPATHS_prepend := "${THISDIR}/initrd-api-part-cfg:"
SRC_URI = "file://runscript.sh"
