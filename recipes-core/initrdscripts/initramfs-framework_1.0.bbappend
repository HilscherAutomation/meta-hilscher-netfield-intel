RDEPENDS_${PN}-base_append += "gptfdisk"
