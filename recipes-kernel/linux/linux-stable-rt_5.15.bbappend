SRC_URI += "file://add_missing_symbols.patch"
